options:
  parameters:
    description: AD9361 (USRP B210) NF measurement capture flowgraph
    generate_options: no_gui
    id: nf_measurement
    output_language: python
    title: AD9361 NF Measurement Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 920e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0'
    clock_source0: internal
    comment: Channel 0, antenna RX2 -- this project's "RX1 port" label, confirmed against the actual bench wiring (there is no literal RX1 antenna string on the B210; only TX/RX and RX2 exist). Set gain via rx_gain variable -- for the full 0-76 gain-index sweep, drive this externally (e.g. scripts/run_nf_sweep.py) rather than by hand-editing this flowgraph per point.
    dev_addr: ''
    gain0: rx_gain
    sample_rate: samp_rate
    sync: unknown_pps
    time_source0: internal
    type: fc32
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: power_logger_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import csv
      import time


      class blk(gr.sync_block):
          """
          Average FFT-bin power (linear mag^2) per frame into a single dBFS
          value, apply dbm_offset (from the absolute power calibration in
          docs/calibration_procedure.md section 6), and append a
          (timestamp, dBm) row to csv_path.

          This block logs raw power only. The hot/cold Y-factor bookkeeping
          and NF calculation are done offline by scripts/nf_yfactor.py against
          the logged values -- this flowgraph is a manual/interactive capture
          aid, not the full automated sweep (use scripts/run_nf_sweep.py for
          that).
          """

          def __init__(self, csv_path='data/raw/capture.csv', vlen=1024, dbm_offset=0.0):
              gr.sync_block.__init__(
                  self,
                  name='power_logger',
                  in_sig=[(np.float32, vlen)],
                  out_sig=None,
              )
              self.vlen = vlen
              self.dbm_offset = dbm_offset
              self.csv_path = csv_path
              self._f = open(csv_path, 'a', newline='')
              self._writer = csv.writer(self._f)

          def work(self, input_items, output_items):
              frame = input_items[0]
              for row in frame:
                  power_lin = np.mean(row)
                  if power_lin <= 0:
                      continue
                  raw_db = 10.0 * np.log10(power_lin)
                  dbm = raw_db + self.dbm_offset
                  self._writer.writerow([time.time(), dbm])
              self._f.flush()
              return len(frame)
    comment: Replace csv_path/dbm_offset as needed. See flowgraphs/README.md.
    csv_path: '''../data/raw/capture.csv'''
    dbm_offset: '0.0'
    vlen: fft_size
  states: {}

connections:
- [usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', power_logger_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
